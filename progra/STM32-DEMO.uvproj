# Keil uVision project STM32-DEMO.uvproj, settings and files
target LED-DEMO (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\FWlib\inc;..\FWlib\src;..\control;..\HWdriver;..\userSrc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_flash.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group HWdrive
    ../HWdriver/: UART1.c stmflash.c Tim.c
  group userSrc
    ../userSrc/: main.c stm32f10x_it.c
  group Readme
    ../: readme.txt
